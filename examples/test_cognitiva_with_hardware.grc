<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_cognitiva_with_hardware</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_ver</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>Device Address</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>name=b100a</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_0</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>cca_mode_</key><value>3</value></param>
<param><key>debug_mask_</key><value>0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>mac_address_</key><value>::1020</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>only_send_if_alive_</key><value>True</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>use_arq_</key><value>True</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>parameter_dwell_delay</key><value>0.001</value></param>
<param><key>parameter_fft_size</key><value>1024</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>parameter_tune_delay</key><value>0.1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>nc -u localhost 52001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2400e6</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>param_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>param_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>mpdu_out</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>payload_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>psdu_out</source_key><sink_key>mpdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
