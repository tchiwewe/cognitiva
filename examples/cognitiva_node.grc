<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cognitiva_node</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>gr-cognitiva</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>value</key><value>2450e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>payoad_in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>payload_out</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>command</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>phy_ver</key><value>2</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>parameter_fft_size</key><value>1024</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>radio_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>label</key><value>radio_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>par_mac_address</value></param>
<param><key>label</key><value>MAC Address</value></param>
<param><key>value</key><value>::1020</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_0</value></param>
<param><key>mac_address_</key><value>par_mac_address</value></param>
<param><key>cca_mode_</key><value>3</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>use_arq_</key><value>True</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>only_send_if_alive_</key><value>True</value></param>
<param><key>debug_mask_</key><value>1</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>0</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>payload_out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>mpdu_out</source_key><sink_key>mpdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>mpdu_out</source_key><sink_key>mpdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>command</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
