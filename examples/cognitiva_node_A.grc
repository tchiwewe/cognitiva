<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_ver</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>cognitiva_spectrum_sense</key>
<param><key>id</key><value>cognitiva_spectrum_sense_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen_</key><value>1024</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>cognitiva_bin_statistics</key>
<param><key>id</key><value>cognitiva_bin_statistics_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen_</key><value>1024</value></param>
<param><key>tune_delay</key><value>0.1</value></param>
<param><key>dwell_delay</key><value>0.2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>debug_mask</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>minsize</key><value>240</value></param>
<param><key>maxsize</key><value>240</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>value</key><value>800e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len_stream</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>param_freq</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>param_freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_0</value></param>
<param><key>mac_address_</key><value>::1020</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>use_arq_</key><value>False</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>broadcast_interval_</key><value>2</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>only_send_if_alive_</key><value>False</value></param>
<param><key>debug_mask_</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>1024</value></param>
<param><key>len_tag_key</key><value>"packet_len_stream"</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>22050</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Match audio sample rate, or just use fifo source</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>Device Address</value></param>
<param><key>value</key><value>name=b100a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>cognitiva_node_a</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>../../../data/music_low_rate_.mp3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cognitiva_spectrum_sense_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>payload out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>payload in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>mpdu out</source_key><sink_key>from_mac</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>to_mac</source_key><sink_key>mpdu in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_spectrum_sense_0</source_block_id><sink_block_id>cognitiva_bin_statistics_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_0</source_block_id><sink_block_id>cognitiva_bin_statistics_0</sink_block_id><source_key>strobe</source_key><sink_key>start</sink_key></connection>
<connection><source_block_id>cognitiva_bin_statistics_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>bins</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>payload in</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
