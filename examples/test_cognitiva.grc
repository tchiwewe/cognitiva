<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_cognitiva</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_ver</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>variable_slider_0/1000</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>1024</value></param>
<param><key>minsize</key><value>1024</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>1400</value></param>
<param><key>minsize</key><value>1400</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_1</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>cca_mode_</key><value>0</value></param>
<param><key>debug_mask_</key><value>0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>mac_address_</key><value>::3040</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>only_send_if_alive_</key><value>True</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>use_arq_</key><value>True</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_2</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>cca_mode_</key><value>0</value></param>
<param><key>debug_mask_</key><value>0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>mac_address_</key><value>"::1020"</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>max_attempts_</key><value>0</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>only_send_if_alive_</key><value>False</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>use_arq_</key><value>True</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>parameter_dwell_delay</key><value>0.001</value></param>
<param><key>parameter_fft_size</key><value>1024</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>parameter_tune_delay</key><value>0.1</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_1</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>parameter_dwell_delay</key><value>0.001</value></param>
<param><key>parameter_fft_size</key><value>1024</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>parameter_tune_delay</key><value>0.1</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>msg_nsamples</key><value>1024</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Node 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Node 2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>nc -u localhost 52001</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>nc -u localhost 52002</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>node1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>node2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>node2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>node1</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_1</source_block_id><sink_block_id>blocks_random_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_2</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_1</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_2</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>cognitiva_cognitiva_mac_1</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_1</source_block_id><sink_block_id>cognitiva_phy_1</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_1</source_block_id><sink_block_id>cognitiva_phy_1</sink_block_id><source_key>mpdu_out</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_1</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>payload_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_2</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_2</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>mpdu_out</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_2</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>payload_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_2</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_2</sink_block_id><source_key>psdu_out</source_key><sink_key>mpdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_phy_1</source_block_id><sink_block_id>cognitiva_cognitiva_mac_1</sink_block_id><source_key>control_out</source_key><sink_key>control_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_1</source_block_id><sink_block_id>cognitiva_cognitiva_mac_1</sink_block_id><source_key>psdu_out</source_key><sink_key>mpdu_in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_1</source_block_id><sink_block_id>foo_packet_pad_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>cognitiva_phy_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
