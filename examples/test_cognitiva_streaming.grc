<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_ver</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Node 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Node 2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_1</value></param>
<param><key>mac_address_</key><value>::3040</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>use_arq_</key><value>False</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>only_send_if_alive_</key><value>True</value></param>
<param><key>debug_mask_</key><value>0</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
</block>
<block>
<key>cognitiva_cognitiva_mac</key>
<param><key>id</key><value>cognitiva_cognitiva_mac_0</value></param>
<param><key>mac_address_</key><value>::1020</value></param>
<param><key>mac_ver_</key><value>0</value></param>
<param><key>use_arq_</key><value>False</value></param>
<param><key>max_attempts_</key><value>10</value></param>
<param><key>timeout_</key><value>0.1</value></param>
<param><key>broadcast_interval_</key><value>2.0</value></param>
<param><key>exp_backoff_</key><value>True</value></param>
<param><key>backoff_randmoness_</key><value>0.05</value></param>
<param><key>node_expiry_delay_</key><value>10.0</value></param>
<param><key>expire_on_arq_failure_</key><value>True</value></param>
<param><key>only_send_if_alive_</key><value>True</value></param>
<param><key>debug_mask_</key><value>0</value></param>
</block>
<block>
<key>cognitiva_phy</key>
<param><key>id</key><value>cognitiva_phy_0_0</value></param>
<param><key>debug_mask</key><value>0</value></param>
<param><key>phy_ver</key><value>phy_ver</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>pad_front</key><value>100</value></param>
<param><key>pad_tail</key><value>100</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>pad_front</key><value>100</value></param>
<param><key>pad_tail</key><value>100</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len_stream</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>1024</value></param>
<param><key>len_tag_key</key><value>"packet_len_stream"</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/tchiwewe/Documents/music_fifo.mp3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>../../../data/music_.mp3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>test_cognitiva_streaming</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>cognitiva_cognitiva_mac_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>mpdu out</source_key><sink_key>from_mac</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0_0</source_block_id><sink_block_id>cognitiva_phy_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_1</sink_block_id><source_key>to_mac</source_key><sink_key>mpdu in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>to_mac</source_key><sink_key>mpdu in</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>foo_packet_pad_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_phy_0_0</source_block_id><sink_block_id>foo_packet_pad_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>cognitiva_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_1</source_block_id><sink_block_id>cognitiva_phy_0_0</sink_block_id><source_key>mpdu out</source_key><sink_key>from_mac</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>cognitiva_cognitiva_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>payload in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cognitiva_cognitiva_mac_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>payload out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
